# Keil uVision project inova_perf_reader_b.uvprojx, settings and files
target LPC1768 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: inova_perf_reader_b +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Helpers\include;.\LPC1768 Drivers\Drivers\include;.\LPC1768 Drivers\Core\CMSIS\include;.\Main\include;..\iNOVA;.\Private Functions\include;.\USB\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Startup
    ./Startup/: system_LPC17xx.c startup_LPC17xx.s
  group Helpers
    ./Helpers/source/: delay.c extintr.c fifo.c gpio.c hlp_gps.c hlp_uart.c hlp_vic.c Retarget.c ringbuf.c iis2mdc_reg.c i2c.c fxas21002.c mma8452q.c sdcard.c spi.c fat32.c json_serialiser.c adc.c
  group LPC1768 Drivers
    ./LPC1768 Drivers/Drivers/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c debug_frmwrk.c
  group Main
    ./: main.c
  group Test
    ./Test/: testing_functions.c
  group Private Functions
    ./Private Functions/source/: peripherals.c
  group USB
    ./USB/source/: usbcore.c usbdesc.c usbhw.c usbuser.c hiduser.c
